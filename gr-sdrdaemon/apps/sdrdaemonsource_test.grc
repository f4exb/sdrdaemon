<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sdrdaemonsource_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>SDRdaemon</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>avg_nb_blocks</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_avg_nb_blocks</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>avg_nb_recovery</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_avg_nb_recovery</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cur_nb_blocks</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_cur_nb_blocks</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cur_nb_recovery</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_cur_nb_recovery</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fc</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_center_freq_khz</value></param>
<param><key>value</key><value>100000</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>fec_txt</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Blks: %d  (%.1f) Rec: %d (%.1f)" % (cur_nb_blocks, avg_nb_blocks, cur_nb_recovery, avg_nb_recovery)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>FEC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip</value></param>
<param><key>value</key><value>"192.168.1.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowcut</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>samp_bits</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_sample_bits</value></param>
<param><key>value</key><value>12</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>get_sample_rate_hz</value></param>
<param><key>value</key><value>200000</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>status_txt</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Fc: %d kHz Sample Rate: %d Hz #bits: %d" % (fc,samp_rate,samp_bits)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Meta</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trans</value></param>
<param><key>value</key><value>cutoff/20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_payload_size</value></param>
<param><key>block_id</key><value>sdrdaemonsource</value></param>
<param><key>function_name</key><value>payload_size</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>200</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>test.iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0/(1&lt;&lt;16)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>sdrdaemon_sdrdaemonsource</key>
<param><key>id</key><value>sdrdaemonsource</value></param>
<param><key>ipaddr</key><value>192.168.1.3</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>512</value></param>
<param><key>port</key><value>9096</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrdaemonsource</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
