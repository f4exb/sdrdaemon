<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sdrdaemonfec_test2</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>SDRdaemon</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>avg_nb_blocks</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_avg_nb_blocks</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>avg_nb_recovery</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_avg_nb_recovery</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cur_nb_blocks</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_cur_nb_blocks</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cur_nb_recovery</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_cur_nb_recovery</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fc</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_center_freq_khz</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>fec_txt</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Blks: %d  (%.1f) Rec: %d (%.1f)" % (cur_nb_blocks, avg_nb_blocks, cur_nb_recovery, avg_nb_recovery)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>FEC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip</value></param>
<param><key>value</key><value>"192.168.1.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowcut</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>samp_bits</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_sample_bits</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>get_sample_rate_hz</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>status_txt</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Fc: %d kHz Sample Rate: %d Hz #bits: %d" % (fc,samp_rate,samp_bits)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Meta</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trans</value></param>
<param><key>value</key><value>cutoff/20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_payload_size</value></param>
<param><key>block_id</key><value>sdrdmn_source</value></param>
<param><key>function_name</key><value>payload_size</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vol</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>200</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>vol</value></param>
<param><key>high_cutoff_freq</key><value>cutoff</value></param>
<param><key>low_cutoff_freq</key><value>lowcut</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>test.iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0/(1&lt;&lt;16)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value>firdes.band_pass(vol,samp_rate,lowcut/24.0,cutoff/24.0,trans/24.0)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>sdrdaemonfec_sdrdmnfec_source</key>
<param><key>id</key><value>sdrdmn_source</value></param>
<param><key>ipaddr</key><value>ip</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>512</value></param>
<param><key>port</key><value>9090</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrdmn_source</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
